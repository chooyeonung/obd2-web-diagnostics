# Repository chooyeonung/obd2-web-diagnostics

File README.md:

# ESP32 기반 차량 OBD-II 웹 진단 시스템

ESP32-S3 + CAN 트랜시버로 차량 OBD-II 포트에 연결하여, 브라우저(웹앱)에서 실시간 차량 진단(센서 모니터링, 고장코드 조회/소거)을 제공하는 시스템.

> **단계 전략**: ① 개인용 프로토타입 → ② 소량 검증(베타) → ③ 판매(제품화)
> 수익의 중심은 하드웨어가 아닌 **웹앱(서비스)**에 둔다. 통신 계층을 ELM327 표준으로 추상화해 "아무 동글이나 꽂아도 되는 진단 서비스"를 먼저 만들고, 자체 하드웨어는 프리미엄 옵션으로 추가한다.

---

## 1. 로드맵

### Phase 1 — 개인용 프로토타입 (지금)

목표: **내 차에서 내 웹앱으로 진단이 되는가?**

- [ ] 부품 구매 (아래 BOM)
- [ ] ELM327 호환 BLE 동글 1개 구매 (웹앱 선행 개발용, 쿠팡 1~3만 원 / 품질 원하면 vLinker MC+)
- [ ] 웹앱: Web Bluetooth로 동글 연결 → 표준 PID 조회(RPM, 냉각수온, 차속) 성공
- [ ] 하드웨어: 개발보드 + 모듈 결선(§4) → 벤치 테스트(CAN 루프백) → 차량 테스트
- [ ] 펌웨어: TWAI(CAN) 수신 → OBD-II 요청/응답 → WebSocket 전송
- [ ] 웹앱 트랜스포트 추상화: 동글(BLE)과 자작 보드(WebSocket) 모두에서 동일 동작 확인

### Phase 2 — 소량 검증 (10~50대)

목표: **다양한 차종에서 검증 + 커스텀 PCB화**

- [ ] KiCad로 아트웍 직접 설계 또는 크몽/설계사무소에 의뢰(2층, 부품 30~40개 → 설계비 약 30~80만 원)
- [ ] JLCPCB 등 PCBA로 소량 제작(이 수량대는 국내 턴키 대비 1/5~1/10 비용)
- [ ] WiCAN 공개 회로도를 전원부/보호회로 레퍼런스로 검토 (회로 참고 OK, 코드 복사 금지 — §7)
- [ ] 베타 사용자 확보: 차종별 진단 데이터 편차 수집 (이 사업의 실질 난이도)
- [ ] 절전 설계 검증: 딥슬립 + 전압 감시(배터리 방전 방지)

### Phase 3 — 판매 (제품화)

목표: **인증 통과 + 리스크 관리 + 양산**

- [ ] KC 전파인증(적합성평가): 완제품 기준 수백만 원. KC 인증된 ESP32-WROOM 모듈 사용으로 시험 범위 축소
- [ ] 배터리 방전 대책 최종화(대기전류 목표 < 1mA), ECU 영향 최소화(리스닝 우선 설계)
- [ ] 약관/면책 고지(차량 연결 기기 특성상 필수)
- [ ] 수백 대 이상 → 국내 턴키 업체(아이씨뱅큐, 샘플피씨비, 제이디앤테크놀로지 등) 견적 비교
- [ ] 펌웨어 라이선스 최종 점검(§7): GPL 코드 미포함 확인

---

## 2. BOM 및 구매처 (Phase 1)

| 부품 | 역할 | 구매처 | 확인가(2026-08) |
|---|---|---|---|
| ESP32-S3-WROOM-1 N8R2 개발보드 | MCU (TWAI/CAN 컨트롤러 내장, WiFi/BLE) | 디바이스마트 (VND032) | 약 14,850원 |
| SN65HVD230 CAN 모듈 (CJMCU-230) | CAN 트랜시버 (3.3V) | 제노몰 / 쿠팡 | 약 1,500~1,820원 |
| LM2596 DC/DC 모듈 (SZH-PWSD-001) | 차량 12V → 5V 강압 | 디바이스마트 | 약 1,650원 |
| SMAJ24A | 입력 서지(TVS) 보호 | 디바이스마트 | 약 1,925원 |
| OBD-II 16핀 Male 커넥터 | 차량 연결 | 쿠팡/네이버 국내배송 | 제품별 상이 |
| (추가) 폴리퓨즈 500mA~1A | 과전류 보호 | 디바이스마트 | 수백 원 |
| (추가) SS34 쇼트키 다이오드 | 역접속 보호 | 디바이스마트 | 수백 원 |
| (선택) PESD1CAN 또는 NUP2105L | CAN 라인 ESD 보호 | 디바이스마트 | 수백 원 |

### 부품별 주의사항

- **SN65HVD230 (CJMCU-230)**: 보드 위 **120Ω 종단저항(보통 R2)을 반드시 제거**할 것. 차량 CAN 버스는 이미 양단 종단되어 있음. 안 떼면 버스 임피던스가 무너져 통신 불안정/타 ECU 영향 가능.
- **LM2596**: 최대 입력 40V — 차량 로드덤프 서지에 마진이 빠듯하므로 SMAJ24A + 퓨즈 + 역접속 다이오드 필수. 무부하 대기전류가 수 mA라 **상시전원(핀 16)에 꽂아두면 배터리 방전 위험** → 장기적으로 저대기전류 레귤레이터 또는 딥슬립+하이사이드 스위치 검토.
- **OBD 커넥터**: "OBD2 16Pin **Male Plug + Shell + Solder/Terminal Pin**" 타입(차량 단자에 직결 + 후면 핀에 직접 배선). 단순 연장케이블 아님. 못 구하면 OBD2 연장케이블을 잘라 사용(테스터로 핀-선색 확인).

---

## 3. OBD-II 커넥터 핀맵 (사용 핀)

| OBD-II 핀 | 신호 | 연결 대상 |
|---|---|---|
| 4 | 섀시 GND | 공통 GND |
| 5 | 시그널 GND | 공통 GND (4번과 함께 묶음) |
| 6 | CAN-H (ISO 15765-4) | SN65HVD230 CANH |
| 14 | CAN-L (ISO 15765-4) | SN65HVD230 CANL |
| 16 | 배터리 +12V (상시) | 퓨즈 → 보호회로 → LM2596 IN |

나머지 핀(K-Line 7/15, J1850 2/10 등)은 Phase 1에서 미사용. CAN(ISO 15765-4)만으로 국내 2008년 이후 차량 대부분 커버(가솔린은 표준 PID 의무 구현).

---

## 4. 회로 결선도 (Phase 1, 모듈 조합)

```
OBD 16 (+12V) ──[폴리퓨즈 1A]──[SS34 ▶]──┬──[LM2596 IN+]
                                          │
                                     [SMAJ24A]   (단방향, 캐소드가 +12V 쪽)
                                          │
OBD 4,5 (GND) ────────────────────────────┴──[LM2596 IN-] ── 공통 GND

LM2596 OUT+ (5.0V로 조정) ──→ ESP32-S3 보드 5V(VIN) 핀
LM2596 OUT- ──→ GND

ESP32-S3 3V3 ──→ SN65HVD230 VCC (3.3V 전용 소자!)
ESP32-S3 GND ──→ SN65HVD230 GND

ESP32-S3 GPIO4 (TWAI TX) ──→ SN65HVD230 D (CTX)
ESP32-S3 GPIO5 (TWAI RX) ──→ SN65HVD230 R (CRX)

SN65HVD230 CANH ──→ OBD 6
SN65HVD230 CANL ──→ OBD 14
(선택) PESD1CAN을 CANH/CANL-GND 사이에 배치
```

### 결선 체크리스트

- [ ] LM2596 출력을 **부하 연결 전** 5.0V로 트리머 조정 (기본값이 높게 온다)
- [ ] SN65HVD230 모듈 120Ω 종단저항 제거 확인
- [ ] SMAJ24A 방향 확인 (단방향: 캐소드 밴드가 +12V 쪽)
- [ ] ESP32-S3에서 GPIO4/5는 TWAI에 자유 배치 가능(GPIO 매트릭스). 스트래핑 핀(GPIO0, 3, 45, 46)은 피할 것
- [ ] 차량 연결 전 벤치에서 12V 어댑터로 전원부 단독 검증
- [ ] (전압 감시용, 권장) 12V → 100k/10k 분압 → ESP32 ADC 핀: 시동 여부 감지(≈13.5V↑) 및 저전압 시 딥슬립

---

## 5. 펌웨어 아키텍처 (자체 작성)

> **처음부터 자체 작성한다.** wican-fw(GPL-3.0) 코드를 가져오면 제품화 시 소스 공개 의무 발생. Apache-2.0/MIT 스택만 사용(§7).

```
┌─────────────────────────────────────────┐
│  Web UI (LittleFS에 정적 파일로 탑재)      │
├─────────────────────────────────────────┤
│  HTTP 서버 + WebSocket (esp_http_server) │
│  WiFi SoftAP (초기) / STA (공유기 접속)    │
├─────────────────────────────────────────┤
│  ELM327 호환 명령 계층 (AT + PID 요청)     │  ← 웹앱과의 계약(contract).
├─────────────────────────────────────────┤     동글이든 자작보드든 동일 인터페이스
│  OBD-II 계층: SAE J1979 (Mode 01/03/04/09)│
│  ISO-TP (ISO 15765-2) 멀티프레임 조립      │
├─────────────────────────────────────────┤
│  TWAI 드라이버 (ESP-IDF, 500 kbps)        │
├─────────────────────────────────────────┤
│  전원 관리: ADC 전압 감시 → 딥슬립          │
└─────────────────────────────────────────┘
```

- 프레임워크: **ESP-IDF** (또는 Arduino-ESP32 코어) — 둘 다 Apache-2.0
- CAN 설정: 500 kbps, 11bit ID 기본(요청 0x7DF, 응답 0x7E8~0x7EF). 일부 차량 29bit(0x18DB33F1) 폴백
- 진단 기능 우선순위: Mode 01(실시간 데이터) → Mode 03(DTC 조회) → Mode 04(DTC 소거) → Mode 09(VIN)
- **웹앱 서빙은 ESP32에서 직접**(LittleFS): 외부 HTTPS 호스팅 시 브라우저 혼합 콘텐츠 정책으로 ws:// 연결이 차단됨
- 안전 원칙: 기본은 **수신 전용**에 가깝게, 전송은 표준 진단 요청만. 임의 CAN 주입 기능은 제품에서 제외

## 6. 웹앱 아키텍처

```
┌───────────────────────────────────────────────┐
│  UI: 대시보드(게이지/차트), DTC 목록·해설, 로그   │
├───────────────────────────────────────────────┤
│  도메인 계층: PID 디코딩 테이블(J1979),          │
│              DTC 데이터베이스(P0xxx 해설)        │
├───────────────────────────────────────────────┤
│  프로토콜 계층: ELM327 명령 생성/응답 파싱        │
├───────────────────────────────────────────────┤
│  트랜스포트 추상화 (인터페이스 1개, 구현 2개)      │
│   ├─ WebSocket  ← 자작 ESP32 보드              │
│   └─ Web Bluetooth(BLE) ← 시판 ELM327 동글      │
└───────────────────────────────────────────────┘
```

- **트랜스포트 추상화가 핵심**: Phase 1에서 동글로 개발한 코드가 자작 보드·WiCAN·향후 자체 제품까지 그대로 재사용됨
- Web Bluetooth는 Chrome/Edge 지원(iOS Safari 미지원 — iOS 대응 필요 시 WebSocket 경로 사용)
- 오프라인 대응: PWA(서비스워커)로 구성하면 지하주차장 등 무네트워크 환경에서도 동작
- 참고 프로젝트: EQM_OBDWEB(ESP32 웹 대시보드 서빙 사례), ELMduino(MIT, PID 파싱 참고), obd-ble-serial(BLE 연결 사례)

---

## 7. 라이선스 전략

| 자산 | 라이선스 | 사용 방침 |
|---|---|---|
| wican-fw 펌웨어 코드 | GPL-3.0 | **코드 복사/개조 금지** (제품화 시 소스 공개 의무 발생). 기능 아이디어 참고만 |
| WiCAN 회로도 (sch/) | GPL-3.0 (저장소) | 회로 토폴로지(설계 개념) 참고는 가능. 파일 자체를 복제·배포하지 않음. Phase 2에서 자체 설계로 재작성 |
| ESP-IDF / Arduino-ESP32 | Apache-2.0 / LGPL | 사용 OK |
| ELMduino | MIT | 사용 OK (파싱 로직 참고/포함 가능) |
| 자체 펌웨어·웹앱 | 자체 결정 | 비공개 유지 가능하도록 GPL 코드 미포함 원칙 유지 |

## 8. 인증·판매 리스크 체크리스트 (Phase 3)

- [ ] **KC 적합성평가(전파인증)**: WiFi/BLE 탑재 완제품은 필수. KC 인증 완료된 ESP32-WROOM 모듈 채택 시 시험 범위 축소되나 완제품 등록은 별도. 예산 수백만 원 단위
- [ ] **배터리 방전**: 상시전원 사용 시 대기전류 스펙 명시(목표 <1mA), 저전압 컷오프 필수
- [ ] **ECU 안전성**: 표준 진단 요청 외 전송 금지, DTC 소거는 사용자 확인 2단계
- [ ] **면책 고지**: 차량 보증/AS 관련 분쟁 대비 약관 명시
- [ ] **경쟁 구도**: 하드웨어 단품은 중국산 저가 동글과 가격 경쟁 불가 → 웹앱 구독/서비스 모델로 차별화
- [ ] **GPL 오염 검사**: 배포 전 펌웨어 의존성 라이선스 전수 확인

---

## 9. 참고 자료

- WiCAN (오픈소스 ESP32 OBD 동글): <https://github.com/meatpiHQ/wican-fw> — 회로 레퍼런스, GPL 주의
- WiCAN Pro (전 프로토콜 지원 상위판, $89): <https://www.crowdsupply.com/meatpi-electronics/wican-pro>
- ELMduino (MIT, ELM327/OBD 파싱): <https://github.com/PowerBroker2/ELMduino>
- EQM_OBDWEB (ESP32 웹 OBD 대시보드): <https://github.com/EQMOD/EQM_OBDWEB>
- obd-ble-serial (Web BLE 연결 예제): <https://github.com/vdvornichenko/obd-ble-serial>
- 국내 PCB/SMT: 아이씨뱅큐 <https://www.icbanq.com/pcb>, 샘플피씨비 <http://www.samplepcb.co.kr/>, PCB아트웍스 <https://pcbartworks.co.kr/>
- 해외 PCBA: JLCPCB <https://jlcpcb.com/>

---

*작성: 2026-08-08 · Phase 1 진행하며 실측값/차종 테스트 결과를 이 문서에 갱신할 것*

## KiCad design hardware/OBD_CAN_ESP32_V2/OBD_CAN_ESP32_V2.kicad_pcb

File hardware/README.md:

# hardware/ — KiCad 회로도

`obd2-gateway.kicad_sch` — 벤치 회로(모듈 단위)의 KiCad 회로도.
KiCad 7 이상에서 열림 (독립 파일이라 프로젝트 없이 더블클릭으로 열려요).

- 연결은 **같은 이름의 부품 사이를 실제 배선(wire)으로 연결한 전통적 스타일 — 선을 따라가며 읽으면 됩니다
- 심볼은 자체 라이브러리(OBD2DIY)로 파일 안에 내장 — 별도 라이브러리 설치 불필요
- 향후 캐리어 보드 아트웍 시 이 회로도에 풋프린트를 지정하고 PCB로 넘기면 됨

kicad-cli 7.0.11로 파싱/SVG 출력 검증 완료.

Parts:
C1: 0.1µF(100nF); C_0805_2012Metric
C10, C11: 2.2µF/100V; C_1210_3225Metric
C12: 100nF/100V; C_0805_2012Metric
C13: 100nF; C_0603_1608Metric
C14, C15: 22µF/16V; C_1206_3216Metric
C16: 3300pF; C_0603_1608Metric
D1: SM8S24A; DO-218AB_SM8S
D2: SZMMSZ12T1G; D_SOD-123
D3: NUP2105L; SOT-23
D10: B360A; D_SMA
F1: 1A; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
J1: OBD-II INPUT; JST_XH_S6B-XH-A_1x06_P2.50mm_Horizontal
J3: ESP32_S3_DEVKITC_J1; PinHeader_1x22_P2.54mm_Vertical
J4: ESP32_S3_DEVKITC_J3; PinHeader_1x22_P2.54mm_Vertical
L1: 10µH 4A; L_Sunlord_SWPA6045S
Q1: SUD50P06-15-GE3; TO-252-2
R1: 100kΩ; R_0805_2012Metric
R2: 0Ω; R_0805_2012Metric
R3: 120Ω DNP; R_0805_2012Metric; not fitted
R10: 52.3kΩ 1%; R_0603_1608Metric
R11: 10kΩ 1%; R_0603_1608Metric
R12: 182kΩ 1%; R_0603_1608Metric
R13: 8.06kΩ; R_0603_1608Metric
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TestPoint; TestPoint_Pad_D2.0mm
U1: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm
U2: TPS54360BDDA; HSOP-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.1mm_ThermalVias

Connections:
/+3V3: C1.2, J3.1, TP5.1 (1_1), U1.3 (VCC)
/+5V: C14.1, C15.1, J3.21, L1.2, R10.1, TP4.1 (1_1)
/CAN_H: D3.1 (K), J1.4, R3.1, TP7.1 (1_1), U1.7 (CANH)
/CAN_L: D3.2 (K), J1.5, R3.2, TP8.1 (1_1), U1.6 (CANL)
/CAN_RX: J3.11, U1.4 (R)
/CAN_TX: J3.10, U1.1 (D)
/CHASSIS_GND: D1.1 (A1), J1.2, R2.1
/SIGNAL_GND: C1.1, C10.2, C11.2, C12.2, C14.2, C15.2, C16.2, D3.3 (A), D10.2 (A), J1.3, J3.22, R1.2, R2.2, R11.2, R12.2, TP6.1 (1_1), U1.2 (GND), U1.8 (Rs), U2.7 (GND), U2.9 (PAD)
/VBAT_FUSED: D1.2 (A2), F1.2, Q1.2 (S), TP2.1 (1_1)
/VBAT_OBD: F1.1, J1.1, TP1.1 (1_1)
/VBAT_PROTECTED: C10.1, C11.1, C12.1, D2.1 (K), Q1.3 (D), TP3.1 (1_1), U2.2 (VIN)
unnamed: C16.1, R13.2
unnamed: D2.2 (A), Q1.1 (G), R1.1
unnamed: C13.2, D10.1 (K), L1.1, U2.8 (SW)
unnamed: C13.1, U2.1 (BOOT)
unnamed: R13.1, U2.6 (COMP)
unnamed: R10.2, R11.1, U2.5 (FB)
unnamed: R12.1, U2.4 (RT/CLK)

Notes on the sheet:
벅 컨버터 (LM2596 모듈 대체) — TPS54360B 5.0V/500kHz

Board: 2 copper layers, 64.0 x 36.0 mm, 39 parts (11 on the bottom side), 18 nets.

Other parts of the board:
H1, H2, H3, H4: M2.5; MountingHole_2.7mm_M2.5

File hardware/OBD_CAN_ESP32_V2/gerber/BOM-jlcpcb.csv:

Comment,Designator,Footprint,LCSC Part #,비고
TPS54360BDDAR,U2,SOIC-8-EP (HSOP-8),C524806,60V 3.5A 벅 컨트롤러
SN65HVD230DR,U1,SOIC-8,C12084,3.3V CAN 트랜시버
B360A,D10,SMA / DO-214AC,C94193,60V 3A 쇼트키 (캐치 다이오드)
SM8S24A,D1,DO-218AB,C314439,24V 자동차용 TVS (단방향)
MMSZ12T1G,D2,SOD-123,C72599,12V 제너 500mW (게이트 클램프)
NUP2105LT1G,D3,SOT-23,C14486,CAN 라인 보호
SUD50P06-15-GE3,Q1,TO-252 (DPAK),C141584,P-ch MOSFET -60V 15mR (역접속 보호)
1812L110/33MR,F1,1812,C142747,PTC 1.1A 33V
SWPA6045S100MT,L1,6.0x6.0x4.5mm,C79272,10uH Isat 3.5A
S6B-XH-A(LF)(SN),J1,JST XH 6P 측면형,C157919,OBD 케이블 입력
2.2uF 100V X7R,"C10,C11",1210,C153036,벅 입력 커패시터
100nF 100V X7R,C12,0805,C28233,VIN 고주파 (Basic)
100nF 50V X7R,C13,0603,C14663,BOOT-SW (Basic)
100nF 50V X7R,C1,0805,C49678,U1 VCC 디커플 (Basic)
22uF 25V X5R,"C14,C15",1206,C12891,벅 출력 (Basic)
3300pF 50V X7R,C16,0603,C1613,COMP (Basic)
52.3k 1%,R10,0603,C23198,FB 상단
10.0k 1%,R11,0603,C25804,FB 하단 (Basic)
182k 1%,R12,0603,C22894,"RT/CLK — 재고 적음, C163428 대체 가능"
8.06k 1%,R13,0603,C23112,COMP 직렬 R
100k,R1,0805,C149504,게이트 풀다운 (Basic)
0R jumper,R2,0805,C17477,섀시-시그널 GND 연결 (Basic)
120R  ** DNP **,R3,0805,C17437,실장 금지 — 차량 버스에 종단 있음
PinHeader 1x22 2.54mm,"J3,J4",THT 1x22,-,데브킷 수납용 — 암헤더 또는 핀헤더 별도 구매
Test pad (구리만),TP1~TP8,D2.0mm 패드,-,부품 없음
M2.5 나사구멍,H1~H4,2.7mm NPTH,-,부품 없음
